# Forces the append to apply specifically to this recipe name, protecting it from global overwrites
IMAGE_INSTALL:append:pn-obmc-phosphor-image = " oob-csm"

